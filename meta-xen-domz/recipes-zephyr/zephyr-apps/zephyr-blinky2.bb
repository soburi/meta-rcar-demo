require zephyr-apps-common.inc

SUMMARY = "Build second Zephyr blinky guest"
ZEPHYR_IMAGE_LINK_NAME = "zephyr_blinky2"
