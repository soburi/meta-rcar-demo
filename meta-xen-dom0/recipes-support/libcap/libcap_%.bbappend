PARALLEL_MAKEINST = ""

#EXTRA_OEMAKE:append:class-target = " \
#    AR='${AR}' \
#    CC='${CC}' \
#    RANLIB='${RANLIB}' \
#    OBJCOPY='${OBJCOPY}' \
#    COPTS='${CFLAGS}' \
#    BUILD_COPTS='${BUILD_CFLAGS}' \
#"
